# IAR project read_write_boot_memory.ewp, settings and files
configuration read_write_boot_memory (ARM, debug)
  General.OGChipSelectEditMenu: AT32F415KBU7-4_v2 ArteryTek -AT32F415KBU7-4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F415KBU7_4; USE_STDPERIPH_DRIVER; AT_START_F415_V1; USE_OTG_DEVICE_MODE
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\project\at32f415_board; ..\..\..\..\middlewares\usb_drivers\inc; ..\..\..\..\middlewares\usbd_class\cdc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: read_write_boot_memory.bin
  ILINK.IlinkOutputFile: read_write_boot_memory.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../project/at32f415_board/: at32f415_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f415.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f415.c
  group firmware
    ../../../../libraries/drivers/src/: at32f415_crm.c at32f415_ertc.c at32f415_flash.c at32f415_gpio.c at32f415_misc.c at32f415_usart.c at32f415_usb.c
  group middleware
    ../../../../middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
    ../../../../middlewares/usb_drivers/src/: usb_core.c usbd_core.c usbd_int.c usbd_sdr.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f415_clock.c at32f415_int.c main.c
